Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Thea Coffee table D100 - ver4.ifc
Time: 2024-12-12T11:42:58
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (6)
Name
 | Thea Coffee table D100_0 - ObjectType: SketchupGroup
 | Thea Coffee table D100_1 - ObjectType: SketchupGroup
 | Thea Coffee table D100_2 - ObjectType: SketchupGroup
 | Thea Coffee table D100_3 - ObjectType: SketchupGroup
 | Thea Coffee table D100_4 - ObjectType: SketchupGroup
 | Thea Coffee table D100_5 - ObjectType: SketchupGroup
